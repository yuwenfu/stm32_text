# Keil uVision project simulate.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: simulate +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\inc;.\start;.\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: main.c stm32f10x_it.c
  group Start
    ./start/: cortexm3_macro.s stm32f10x_vector.s
  group Lib
    ./lib/src/: stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c
