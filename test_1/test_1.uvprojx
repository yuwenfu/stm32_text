# Keil uVision project test_1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test_1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: VECT_TAB_RAM
  c include: .\lib\inc;.\start;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x4000
  group StartGroup
    ./start/: cortexm3_macro.s stm32f10x_vector.s
  group LibGroup
    ./lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UserGroup
    ./User/: main.c stm32f10x_it.c
  group HeadGroup
    ./User/: stm32f10x_it.h
    ./lib/inc/: stm32f10x_lib.h stm32f10x_sdio.h cortexm3_macro.h ip_arp_udp_tcp.h LCD1620.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_tim1.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h TYC_GPIO_Init.h UET_GPIO.h
